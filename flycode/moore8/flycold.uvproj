# Keil uVision project flycold.uvproj, settings and files
target flyclod (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk_sizhou +hex
  AfterMake: fromelf --bin --output .\obj\bk_sizhou.bin .\obj\bk_sizhou.axf
  AfterMake: BinConvert -oad obj\bk_sizhou.bin -v 0x1111 -e 00000000 00000000 00000000 00000000
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: GYRO_MPU6050
  c misc: --c99
  c include: .\Math;.\drivers;.\app\include;.\addon
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x400000 size 0x6000
  scatter file: .\bk2471\beken.txt
  link misc: --entry "Vectors"
  group app
    ./app/: main.c my_control.c
  group core
    ./bk2471/common/: common.c
    ./bk2471/Core/: exception.c
    ./bk2471/drivers/flash/: flash_drv.c
    ./bk2471/drivers/i2c/: i2c_drv.c
    ./bk2471/drivers/icu/: icu_drv.c
    ./bk2471/drivers/rf24/: rf_drv.c
    ./bk2471/drivers/timer/: timer_drv.c
    ./bk2471/drivers/uart/: uart_drv.c
    ./bk2471/drivers/enter_ota/: enter_ota.c
  group startup
    ./bk2471/startup/: Init.s Vectors.s
  group driver
    ./drivers/: BK_Drv_Nrf24l01.c BK_Drv_EEPROM.c BK_Drv_MPU6050.c BK_Motor.c BK_RC.c
  group addon
    ./drivers/: thread_imu.c
    ./addon/: board.c debug.c
